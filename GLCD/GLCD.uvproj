# Keil uVision project GLCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: GLCD
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c font5x8.h graphic.c graphic.h KS0108.h KS0108-8051.c delay.c delay.h KS0108.c
